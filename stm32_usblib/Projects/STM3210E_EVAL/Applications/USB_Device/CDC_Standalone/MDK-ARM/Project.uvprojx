# Keil uVision project Project.uvprojx, settings and files
target USB2UartLib (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F103RC STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.3.0
  cpu: IROM(0x08000000,0x40000) IRAM(0x20000000,0xC000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: USBLib (library)
  c flags: Optim=4 OneElfS=1 wLevel=2
  c define: USE_HAL_DRIVER,STM32F103xG,USE_STM3210E_EVAL
  c misc: --C99
  c include: ../Inc;../../../../../../Drivers/CMSIS/Device/ST/STM32F1xx/Include;../../../../../../Drivers/STM32F1xx_HAL_Driver/Inc;../../../../../../Drivers/BSP/STM3210E_EVAL;../../../../../../Middlewares/ST/STM32_USB_Device_Library/Core/Inc;../../../../../../Middlewares/ST/STM32_USB_Device_Library/Class/CDC/Inc
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0xc000
  link misc: --diag_suppress=L6329
  group Middlewares/STM32_USBD_Library/Core
    ../../../../../../Middlewares/ST/STM32_USB_Device_Library/Core/Src/: usbd_ctlreq.c usbd_ioreq.c usbd_core.c
  group Application/User
    ../Src/: usbd_desc.c stm32f1xx_hal_msp.c main.c stm32f1xx_it.c usbd_cdc_interface.c usbd_conf.c system_stm32f1xx.c usblib.h
  group Middlewares/STM32_USBD_Library/Class/CDC
    ../../../../../../Middlewares/ST/STM32_USB_Device_Library/Class/CDC/Src/: usbd_cdc.c
  group Drivers/STM32F1xx_HAL_Driver
    ../../../../../../Drivers/STM32F1xx_HAL_Driver/Src/: stm32f1xx_hal_uart.c stm32f1xx_hal_rcc.c stm32f1xx_hal_cortex.c stm32f1xx_hal.c stm32f1xx_hal_tim.c stm32f1xx_hal_pcd.c stm32f1xx_hal_rcc_ex.c stm32f1xx_hal_rtc.c stm32f1xx_hal_gpio.c stm32f1xx_hal_tim_ex.c stm32f1xx_hal_dma.c stm32f1xx_hal_rtc_ex.c stm32f1xx_ll_usb.c stm32f1xx_hal_pcd_ex.c
software components: CMSIS:CORE 4.1.0
